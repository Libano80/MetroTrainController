# Keil uVision project Blinky.uvproj, settings and files
target STM32F103 Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_StdPeriph_Driver\inc, .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Files
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group System Files
    ./: Retarget.c
    ./: stm32f10x_it.c
  group Source Files
    ./: Blinky.c
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c misc.c
    ./: pins_definition.h EXTI_pins_info.h EXTI_pins_configuration.c EXTI_pins_configuration.h BrakingController.c BrakingController.h EngineController.c EngineController.h LeverController.c LeverController.h
  group Documentation
    ./: Abstract.txt
  group Configuration
    ./: RTX_Config.c
target STM32F103 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
